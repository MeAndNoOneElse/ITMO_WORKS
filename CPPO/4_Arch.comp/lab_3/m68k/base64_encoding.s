 .data
stack_top:       .word  0x1000             ; Вершина стека (адрес 0x1000)
input_ptr:       .word  0x80               ; Указатель на адрес входного порта
output_ptr:      .word  0x84               ; Указатель на адрес выходного порта
inbuf:           .byte  '________________________________________________________________' ; Буфер для входных данных (64 байта)

    .text
    .org     0x88                           

_start:

    movea.l  stack_top, A7                   ; A7 = 0x1000 (указатель стека)
    movea.l  (A7), A7                        ; A7 = значение, хранящееся по адресу 0x1000

    movea.l  input_ptr, A0                   ; A0 = указатель на адрес входного порта
    movea.l  (A0), A0                        ; A0 = адрес входного порта (0x80)


    movea.l  output_ptr, A1                  ; A1 = указатель на адрес выходного порта
    movea.l  (A1), A1                        ; A1 = адрес выходного порта (0x84)


    movea.l  inbuf, A2                       ; A2 = адрес начала буфера
    jsr      read_loop                       ; Вызов функции чтения


    movea.l  inbuf, A2                       ; A2 = снова указывает на начало буфера
    jsr      encode_base64                   ; Вызов функции кодирования

    halt                                     ; Останов программы


read_loop:
    move.b   (A0), D0                        ; Читаем один байт из входного порта в D0
    cmp.b    10, D0                          ; Сравниваем с символом '\n'
    beq      done                            ; Если '\n' - заканчиваем чтение
    cmp.l    63, D6                          ; Проверяем, прочитали ли уже 63 символа (максимум 64)
    beq      overflow                        ; Если 63 - переполнение 

    move.b   D0, (A2)+                       ; Сохраняем символ в буфер и увеличиваем указатель
    add.l    1, D6                           ; Увеличиваем счетчик прочитанных символов
    jmp      read_loop                       ; Продолжаем чтение

overflow:
    move.l   -858993460, (A1)                ; Выводим код ошибки (0xCCCCCCCC) в выходной порт
    halt                                     

done:
    rts                                      ; Возврат из функции (D6 содержит длину строки)


encode_base64:
    movea.l  inbuf, A2                       ; Устанавливаем указатель на начало буфера
    clr.l    D7                              ; D7 = счетчик обработанных байтов (обнуляем)

encode_loop:
    cmp.l    D6, D7                          ; Сравниваем обработанные байты с общим количеством
    bge      encode_done                     ; Если обработали все - выходим

    ; Чтение первого байта группы
    clr.l    D2                              ; Очищаем D2 (для 32-битного значения)
    move.b   (A2)+, D2                       ; Загружаем байт в младший байт D2, увеличиваем указатель
    add.l    1, D7                           ; Увеличиваем счетчик обработанных байтов

    cmp.l    D6, D7                          ; Проверяем, был ли это последний байт
    beq      enc_one                         ; Если да - обрабатываем как 1 байт

    ; Чтение второго байта группы
    clr.l    D3                              ; Очищаем D3
    move.b   (A2)+, D3                       ; Загружаем второй байт
    add.l    1, D7                           ; Увеличиваем счетчик

    cmp.l    D6, D7                          ; Проверяем, был ли это последний байт
    beq      enc_two                         ; Если да - обрабатываем как 2 байта

    ; Чтение третьего байта группы
    clr.l    D4                              ; Очищаем D4
    move.b   (A2)+, D4                       ; Загружаем третий байт
    add.l    1, D7                           ; Увеличиваем счетчик

    move.l   D2, D0
    lsr.l    2, D0
    jsr      to_base64_char
    move.b   D0, (A1)                        ; Выводим первый символ

    move.l   D2, D0
    and.l    3, D0
    asl.l    4, D0
    move.l   D3, D1
    lsr.l    4, D1
    or.l     D1, D0
    jsr      to_base64_char
    move.b   D0, (A1)                        ; Выводим второй символ

    move.l   D3, D0
    and.l    15, D0
    asl.l    2, D0
    move.l   D4, D1
    lsr.l    6, D1
    or.l     D1, D0
    jsr      to_base64_char
    move.b   D0, (A1)                        ; Выводим третий символ

    move.l   D4, D0
    and.l    63, D0
    jsr      to_base64_char
    move.b   D0, (A1)                        ; Выводим четвертый символ

    jmp      encode_loop                     ; Переходим к следующей группе


enc_two:
    move.l   D2, D0
    lsr.l    2, D0
    jsr      to_base64_char
    move.b   D0, (A1)                        ; Первый символ

    move.l   D2, D0
    and.l    3, D0
    asl.l    4, D0
    move.l   D3, D1
    lsr.l    4, D1
    or.l     D1, D0
    jsr      to_base64_char
    move.b   D0, (A1)                        ; Второй символ

    move.l   D3, D0
    and.l    15, D0
    asl.l    2, D0
    jsr      to_base64_char
    move.b   D0, (A1)                        ; Третий символ

    move.b   61, (A1)                        ; Четвертый символ - '='
    jmp      encode_done


enc_one:
    move.l   D2, D0
    lsr.l    2, D0
    jsr      to_base64_char
    move.b   D0, (A1)                        ; Первый символ

    move.l   D2, D0
    and.l    3, D0
    asl.l    4, D0
    jsr      to_base64_char
    move.b   D0, (A1)                        ; Второй символ

    move.b   61, (A1)                        ; Третий символ - '='
    move.b   61, (A1)                        ; Четвертый символ - '='

encode_done:
    rts                                      ; Возврат из функции


to_base64_char:
    move.l   D1, -(A7)                       ; Сохраняем D1 в стеке
    move.l   D0, D1                          ; Копируем входное число в D1

    cmp.l    25, D1                          ; Проверяем: число <= 25?
    bgt      lower                           ; Если нет - переходим к проверке на строчные буквы
    add.l    65, D1                          ; Добавляем 65 -> получаем 'A'-'Z'
    jmp      return

lower:
    cmp.l    51, D1                          ; Проверяем: число <= 51?
    bgt      digit                           ; Если нет - переходим к цифрам
    sub.l    26, D1                          ; Вычитаем 26 (чтобы получить 0-25)
    add.l    97, D1                          ; Добавляем 97 -> получаем 'a'-'z'
    jmp      return

digit:
    cmp.l    61, D1                          ; Проверяем: число <= 61?
    bgt      plus                            ; Если нет - переходим к '+'
    sub.l    52, D1                          ; Вычитаем 52 (чтобы получить 0-9)
    add.l    48, D1                          ; Добавляем 48 -> получаем '0'-'9'
    jmp      return

plus:
    cmp.l    62, D1                          ; Проверяем: число = 62?
    bne      slash                           ; Если нет - это '/'
    move.l   43, D1                          ; '+' (код 43)
    jmp      return

slash:
    move.l   47, D1                          ; '/' (код 47)

return:
    move.b   D1, D0                          ; Перемещаем результат в D0 (младший байт)
    move.l   (A7)+, D1                       ; Восстанавливаем D1 из стека
    rts